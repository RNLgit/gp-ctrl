File: sch/controller.kicad_sch (KiCad schematic)
At the start: 28 parts

Commit message: sch and pcb layout update
Parts:
- gave numbers to parts that had none: 28
